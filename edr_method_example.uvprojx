# Keil uVision project edr_method_example.uvprojx, settings and files
target edr_test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: edr_method_example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC
  c include: .\Source;..\F3_Drivers\STM32F3xx_HAL_Driver\Inc;..\F3_Drivers\CMSIS\Include;..\F3_Drivers\CMSIS\Device\ST\STM32F3xx\Include;D:\SVN_PROJELER\Project_Child_Sense\Child_Sense_Working\Source_Code\F3_Drivers\HW_uart_bundle
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group system
    ./Source/: options_stm32f303xc.s startup_stm32f303xc.s
  group source
    ./Source/: main.c system_stm32f3xx.c stm32f3xx_hal_msp.c stm32f3xx_it.c
    D:/SVN_PROJELER/Project_Child_Sense/Child_Sense_Working/Source_Code/F3_Drivers/HW_uart_bundle/: uart_bundle.c
  group framework
    ../F3_Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c
